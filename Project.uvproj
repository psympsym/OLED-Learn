# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver\inc;.\User;.\Driver\OLED
  group User
    ./User/: main.c STC8Ax_Init.c uart_printf.c
  group STC8Ax_LIB
    ./Driver/src/: STC8A_Delay.c STC8A_GPIO.c STC8A_Timer.c
  group Driver
    ./Driver/OLED/: OLED.c
